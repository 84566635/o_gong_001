# Keil uVision project solo_mpu.uvproj, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: solo_mpu +hex
  c flags: Optim=4
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\user\inc;.\stdperiph_driver\inc;.\cmsis;D:\Keil_v5\ARM\RV31\INC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./startup/: startup_stm32f10x_md.s
  group cmsis
    ./cmsis/: core_cm3.c system_stm32f10x.c
  group user
    ./user/src/: sys.c stm32f10x_it.c interrup_init.c main.c bsp.c bsp_ir_decode.c bsp_key.c bsp_led.c bsp_timer.c HT1621.c
  group stdperiph_driver
    ./stdperiph_driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_gpio.c
